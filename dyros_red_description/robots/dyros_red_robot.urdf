Commit message: wholebody

File: dyros_red_description/robots/dyros_red_robot.urdf (robot description, URDF)
Before this commit: robot dyros_red_description, 33 links, 32 joints
Links:
- removed link world
- added link base_link
Joints:
- joint virtual: parent world -> base_link
